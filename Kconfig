## Kconfig
```kconfig
menu "TarableINA226"

config INA226_USE_FP
    default y
    bool "Use floating point for calculations"

endmenu
```
